# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: GD32F103CB GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.3
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=4 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, GD32F10X_MD, __RTTHREAD__, RT_USING_ARM_LIBC, __CLK_TCK=RT_TICK_PER_SECOND
  c include: applications;.;..\..\Modules\rt-thread\components\libc\compilers\common;..\..\Modules\rt-thread\components\libc\compilers\common\extension;..\..\Modules\rt-thread\libcpu\arm\common;..\..\Modules\rt-thread\libcpu\arm\cortex-m3;..\..\Modules\rt-thread\components\drivers\include;..\..\Modules\rt-thread\components\drivers\include;..\..\Modules\rt-thread\components\drivers\include;board;board\libraries\gd32_drivers;..\..\Modules\rt-thread\components\finsh;.;..\..\Modules\rt-thread\include;board\libraries\GD32F10x_Firmware_Library\CMSIS\GD\GD32F10x\Include;board\libraries\GD32F10x_Firmware_Library\CMSIS;board\libraries\GD32F10x_Firmware_Library\GD32F10x_standard_peripheral\Include;..\..\Modules\rt-thread\components\libc\posix\io\poll;..\..\Modules\rt-thread\components\libc\posix\io\stdio;..\..\Modules\rt-thread\components\libc\posix\ipc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../Modules/rt-thread/components/libc/compilers/armlibc/: syscalls.c syscall_mem.c
    ../../Modules/rt-thread/components/libc/compilers/common/: time.c stdlib.c
  group CPU
    ../../Modules/rt-thread/libcpu/arm/common/: div0.c showmem.c backtrace.c
    ../../Modules/rt-thread/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../Modules/rt-thread/components/drivers/ipc/: waitqueue.c ringblk_buf.c dataqueue.c completion.c ringbuffer.c workqueue.c pipe.c
    ../../Modules/rt-thread/components/drivers/misc/: pin.c
    ../../Modules/rt-thread/components/drivers/serial/: serial.c
  group Drivers
    board/libraries/GD32F10x_Firmware_Library/CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_md.s
    board/: board.c
    board/libraries/gd32_drivers/: drv_gpio.c drv_usart.c
  group Finsh
    ../../Modules/rt-thread/components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../Modules/rt-thread/src/: components.c mempool.c object.c clock.c mem.c irq.c device.c kservice.c ipc.c idle.c thread.c scheduler.c timer.c
  group Libraries
    board/libraries/GD32F10x_Firmware_Library/GD32F10x_standard_peripheral/Source/: gd32f10x_exti.c gd32f10x_gpio.c gd32f10x_misc.c gd32f10x_rcu.c gd32f10x_usart.c
    board/libraries/GD32F10x_Firmware_Library/CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
software components: CMSIS:CORE 5.6.0
